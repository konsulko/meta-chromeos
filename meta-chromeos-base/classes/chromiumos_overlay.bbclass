# Helper class to use files from chromiumos-overlay

require recipes-chromeos/chromiumos-overlay/chromiumos-overlay.inc

S = "${WORKDIR}/src/third_party/chromiumos-overlay/chromeos-base/${BPN}"
