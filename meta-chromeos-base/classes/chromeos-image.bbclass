inherit core-image

CHROMEOS_IMAGE_EXTRA_INSTALL ?= ""
