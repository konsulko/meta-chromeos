# Helper class to use files/scripts from chromite

require recipes-chromeos/chromite/chromite.inc

CHROMITE_ROOT_DIR = "${WORKDIR}/chromite"
CHROMITE_BIN_DIR = "${CHROMITE_ROOT_DIR}/scripts"
