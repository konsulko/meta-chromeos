require chromeos-dbus-bindings_0.0.1.bb
inherit native
COMPATIBLE_MACHINE = "(^$)"
